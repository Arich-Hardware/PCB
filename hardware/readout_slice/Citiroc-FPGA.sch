File: hardware/readout_slice/Citiroc-FPGA.sch (KiCad schematic (older format))
At the start: 18 parts

Commit message: more on readout_slice
Other:
- moved on the sheet: C?, U?G, U?H
